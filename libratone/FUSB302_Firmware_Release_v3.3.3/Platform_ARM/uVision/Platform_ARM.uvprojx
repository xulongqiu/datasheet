# Keil uVision project Platform_ARM.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Platform_ARM +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: STM32F072xB, STM32F072RBT6, PLATFORM_ARM, HSI48_VALUE=48000000, USE_USB_CLKSOURCE_CRSHSI48, FSC_HAVE_VDM, FSC_HAVE_DP, FSC_HAVE_SRC, FSC_HAVE_SNK, FSC_HAVE_DRP, FSC_HAVE_ACCMODE
  c misc: --gnu
  c include: ../..;../app;../../core;../../core/vdm;C:\ARM\STM32Cube_FW_F0_V1.3.0\Drivers\CMSIS\Include;C:\ARM\STM32Cube_FW_F0_V1.3.0\Drivers\CMSIS\Device\ST\STM32F0xx\Include;C:\ARM\STM32Cube_FW_F0_V1.3.0\Drivers\BSP\STM32F072B-Discovery;C:\ARM\STM32Cube_FW_F0_V1.3.0\Drivers\STM32F0xx_HAL_Driver\Inc;C:\ARM\STM32Cube_FW_F0_V1.3.0\Middlewares\ST\STM32_USB_Device_Library\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Core
    ../../core/: AlternateModes.c core.c fusb30X.c Log.c PDPolicy.c PDProtocol.c TypeC.c
    ../../core/vdm/: bitfield_translators.c vdm.c vdm_callbacks.c vdm_config.c
    ../../core/vdm/DisplayPort/: configure.c dp.c dp_system_stubs.c
  group Platform
    ../app/: HostComm.c HWIO.c main.c PlatformI2C.c stm32f0xx_it.c TimeDelay.c Timing.c usbd_conf.c usbd_desc.c usbd_hid.c
    ./: startup_stm32f072.s
  group USB
    C:/ARM/STM32Cube_FW_F0_V1.3.0/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../app/: usbd_main.c
  group HAL
    C:/ARM/STM32Cube_FW_F0_V1.3.0/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_cec.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_irda.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_msp_template.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_smartcard.c stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_smbus.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_wwdg.c
  group System
    C:/ARM/STM32Cube_FW_F0_V1.3.0/Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
software components: CMSIS:CORE 4.2.0
